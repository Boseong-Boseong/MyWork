# IAR project Work.ewp, settings and files
configuration Work (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446VE ST STM32F446VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Core/Src; ../Core/Src/App; ../Core/Src/App/SSD1322; ../Core/Inc/Peripheral_Interfaces; ../Core/Inc/IScreen; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Work.hex
  ILINK.IlinkOutputFile: Work.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/User/Core/Inc
    ../Core/Inc/: crc.h gpio.h main.h spi.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group Application/User/Core/Inc/IScreen
    ../Core/Inc/IScreen/: IScreen.h
  group Application/User/Core/Inc/Peripheral_Interfaces
    ../Core/Inc/Peripheral_Interfaces/: IGpio_STM32.h ISpi.h
  group Application/User/Core/Src
    ../Core/Src/: crc.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group Application/User/Core/Src/App
    ../Core/Src/App/: MyProj.cpp MyProj.h
  group Application/User/Core/Src/App/SSD1322
    ../Core/Src/App/SSD1322/: SSD1322.cpp SSD1322.h SSD1322_Api.cpp SSD1322_Api.h SSD1322_Gfx.cpp ssd1322_gfx.h SSD1322_Gpio.cpp SSD1322_Gpio.h SSD1322_Spi.cpp SSD1322_Spi.h
  group Application/User/Core/Src/App/SSD1322/Fonts
    ../Core/Inc/SSD1322/Fonts/: FreeMono12pt7b.h FreeSansOblique9pt7b.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
